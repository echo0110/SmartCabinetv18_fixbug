# Keil uVision project bootload.uvprojx, settings and files
target bootload (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootload +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ../OBJ/bootload.bin ../OBJ/bootload.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\ADXL345;..\HARDWARE\DS18B20;..\HARDWARE\NRF24L01;..\HARDWARE\SRAM;..\MALLOC;..\HARDWARE\SD;..\FATFS\exfuns;..\FATFS\src;..\USMART;..\FATFS\src\option;..\HARDWARE\SDIO;..\HARDWARE\FLASH;..\USB\CONFIG;..\USB\STM32_USB-FS-Device_Driver\inc;..\HARDWARE\W25QXX;..\IAP;..\HARDWARE\STMFLASH;..\MD5;..\FreeRTOS;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\include;..\HARDWARE\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../FATFS/src/option/: mycc936.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_flash.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USB_CORE
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c
  group IAP
    ../IAP/: iap.c
  group MD5
    ../MD5/: MD5.c
