# Keil uVision project SmartCabinet.uvprojx, settings and files
target SmartCabinet (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartCabinet +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ../OBJ/SmartCabinet.bin ../OBJ/SmartCabinet.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\SNMP;..\HARDWARE\TIMER;..\HARDWARE\DM9000;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip-1.4.1\src\core\snmp_private_mib;..\HARDWARE\SRAM;..\FATFS\src;..\FATFS\exfuns;..\USB\STM32_USB-FS-Device_Driver\inc;..\USB\CONFIG;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\HARDWARE\SDIO;..\HTTP;..\INI;..\SYSTEM\rtc;..\SYSTEM\print;..\HARDWARE\GSM;..\HARDWARE\GPS;..\HARDWARE\OLED;..\HARDWARE\DMA;..\HARDWARE\ADC;..\MQTT;..\HARDWARE\SENSOR;..\HARDWARE\USART3;..\HARDWARE\LED;..\HARDWARE\snmp;..\LWIP\lwip_app\web_server_demo;..\HARDWARE\MD5;..\LWIP\lwip-1.4.1\src\core;..\LWIP\lwip-1.4.1\src\core\snmp_private_mib;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\core\snmp;..\HARDWARE\snmp;..\HARDWARE\MD5;..\LWIP\lwip-1.4.1\src\include\lwip;..\HARDWARE\MD5;..\HARDWARE\camera;..\LWIP\lwip_app\udp_demo;..\SYSTEM\usart;..\SD;..\spi1;..\LWIP\lwip_app\tcp_client_demo;..\STM32F10x_FWLib\src;..\STM32F10x_FWLib\inc;..\LWIP\lwip_app\tcp_server_demo;..\HARDWARE\TIMER;..\HARDWARE\IWDG;..\HARDWARE\IWDG;..\HARDWARE\IWDG;..\LWIP\lwip-1.4.1\src\include\ipv4\lwip;..\HARDWARE\snmp
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c shell.c
  group HARDWARE
    ../HARDWARE/DM9000/: dm9000.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/GSM/: gsm.c
    ../HARDWARE/SENSOR/: sensor.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/snmp/: trap.cpp
  group SYSTEM
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ADC/: adc.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/rtc/: rtc.c
    ../SYSTEM/print/: print.c
    ../SYSTEM/usart/: usart1.c usart2.c usart4.c
    ../HARDWARE/USART3/: usart3.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_iwdg.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group LWIP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/arch/: sys_arch.c
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group USB
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ../USB/CONFIG/: mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c hw_config.c
  group HTTP
    ../HTTP/: webserver.c
  group INI
    ../INI/: minIni.c
  group MQTT
    ../MQTT/: mqttlib.lib mqtt.c
  group LWIP_APP
    ../LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
    ../LWIP/lwip_app/tcp_client_demo/: tcp_client_demo.c
    ../LWIP/lwip_app/tcp_server_demo/: tcp_server_demo.c
  group MD5
    ../HARDWARE/MD5/: MD5.c
  group SNMP
    ../LWIP/lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../LWIP/lwip-1.4.1/src/core/snmp_private_mib/: lwip_prvmib.c
  group Camera
    ../HARDWARE/camera/: camera.c
  group SD
    ../SD/: MMC_SD.C
    ../spi1/: spi1.c
  group IWDG
    ../HARDWARE/IWDG/: iwdg.c
